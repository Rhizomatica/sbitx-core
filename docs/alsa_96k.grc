options:
  parameters:
    generate_options: qt_gui
    id: sound_sour
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '96000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.607106781'
    freq: '2320'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:3,0,1
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: hw:0,0
    num_outputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showrf: 'True'
    type: float
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', audio_sink_0, '0']
- [audio_source_0, '0', qtgui_sink_x_0, '0']
- [audio_source_0, '1', blocks_null_sink_0, '0']
- [audio_source_0, '1', qtgui_sink_x_0_0, '0']

metadata:
  file_format: 1
